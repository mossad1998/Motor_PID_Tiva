# IAR project Motor_Driver_V1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ADC_Driver.c ADC_Driver.h Clock_Driver.c Clock_Driver.h Debug_Driver.c Debug_Driver.h GPIO_Driver.c GPIO_Driver.h main.c PWM_Driver.c PWM_Driver.h tm4c123gh6pm.h
